File: OSH_Park_2_layer/OSH_Park_2_layer.kicad_sch (KiCad schematic)
At the start: 2 parts

Commit message: updated to kicad V8
